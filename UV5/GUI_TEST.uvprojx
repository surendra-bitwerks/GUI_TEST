# Keil uVision project GUI_TEST.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: LPC1766 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GUI_TEST
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../SRC/: main.c
software components: CMSIS:CORE 5.4.0, CMSIS Driver:I2C 2.5.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
